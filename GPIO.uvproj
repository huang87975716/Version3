# Keil uVision project GPIO.uvproj, settings and files
target STM32 (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: GPIO +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: .\CMSIS;.\USER;.\FWlib\inc;.\FWlib\src
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group CMSIS
    ./CMSIS/: core_cm3.c system_stm32f10x.c
  group FWlib
    ./FWlib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_exti.c stm32f10x_usart.c stm32f10x_tim.c stm32f10x_i2c.c stm32f10x_can.c stm32f10x_adc.c stm32f10x_dma.c
  group USER
    ./USER/: main.c stm32f10x_it.c GPIO.c SysTick.c exti.c pwm_output.c matrix_motor.c usart.c adc.c PCF8574_I2C.c
  group STARTCODE
    ./CMSIS/Startup/: startup_stm32f10x_md.s
